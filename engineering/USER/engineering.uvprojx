# Keil uVision project engineering.uvprojx, settings and files
target engineering (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: engineering +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,MPU6500,EMPL_TARGET_STM32F4,MPL_LOG_NDEBUG=1,EMPL
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\FWLIB\inc;..\BSP\inc;..\Driver\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\TASK\inc;..\DMP\driver\eMPL;..\DMP\driver\include;..\DMP\driver\stm32L;..\DMP\eMPL-hal;..\DMP\mllite;..\DMP\mpl;..\Driver\src;..\BSP\src;..\TASK\src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f427xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_i2c.c stm32f4xx_spi.c
  group BSP
    ../BSP/src/: bsp_can.c bsp_dma.c bsp_gpio.c bsp_nvic.c bsp_tim.c bsp_uart.c
  group TASK
    ../TASK/src/: task_control.c task_imu.c task_led.c task_sysinit.c task_chassis.c
  group DRIVER
    ../Driver/src/: driver_arm.c driver_claw.c driver_island.c driver_control.c driver_dbus.c driver_iic.c driver_imu.c driver_judge.c driver_encoder.c
  group DMP
    ../DMP/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../DMP/driver/stm32L/: log_stm32.c
    ../DMP/eMPL-hal/: eMPL_outputs.c
    ../DMP/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../DMP/mpl/: libmpllib.lib
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
